# Autodesk Inventor assembly: 28.0180 COUPLING 20
## iProperties
Created: 2007-06
Part Number: 28.0180 COUPLING 20
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
